do_compile_prepend() {
        if [ "${MACHINE}" = "sm2s-rzv2l" ]; then
                BOARD="RZV2L_SMARC_PMIC";
        fi
}
